# Avahi/mDNS service discovery is not used in the Odoo POS kiosk image.
SYSTEMD_AUTO_ENABLE:avahi-daemon = "disable"

