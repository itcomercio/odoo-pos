# Bluetooth is not used in the Odoo POS kiosk image.
SYSTEMD_AUTO_ENABLE:${PN} = "disable"

