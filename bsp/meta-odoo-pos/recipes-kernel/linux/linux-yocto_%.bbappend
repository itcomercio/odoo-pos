FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://vga-console.cfg file://usb-printer.cfg"

